FILESEXTRAPATHS:append := ":${THISDIR}/xsa"
SRC_URI  := "file://navigator_7020.xsa"
HDF_BASE:zynq = "file://"
HDF_PATH:zynq = "navigator_7020.xsa"
