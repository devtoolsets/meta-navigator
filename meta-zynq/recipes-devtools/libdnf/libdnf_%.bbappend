FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-1558-Don-not-assume-inclusion-of-cstdint.patch"

